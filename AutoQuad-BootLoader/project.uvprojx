# Keil uVision project project.uvprojx, settings and files
target AutoQuad (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;easyflash\inc;easyflash\plugins\types;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\CMSIS\Include;rt-thread-2.1.0\include;rt-thread-2.1.0\libcpu\arm\cortex-m4;rt-thread-2.1.0\libcpu\arm\common;rt-thread-2.1.0\components\drivers\include;rt-thread-2.1.0\components\drivers\include;rt-thread-2.1.0\components\drivers\include;rt-thread-2.1.0\components\finsh;rt-thread-2.1.0\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\autoquad.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c toflash.c
    ./applications/: app_easyflash.c bootloader.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c
  group easyflash
    easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    easyflash/port/: ef_port.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    rt-thread-2.1.0/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    rt-thread-2.1.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    rt-thread-2.1.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    rt-thread-2.1.0/components/drivers/misc/: pin.c
    rt-thread-2.1.0/components/drivers/serial/: serial.c
    rt-thread-2.1.0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    rt-thread-2.1.0/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Utilities
    rt-thread-2.1.0/components/utilities/ymodem/: ymodem.c
